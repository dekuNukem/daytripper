# Keil uVision project gps_logger_new.uvprojx, settings and files
target gps_logger_new (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: gps_logger_new
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c misc: --C99
  c include: ../Inc;      ../Drivers/STM32F0xx_HAL_Driver/Inc;      ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FatFs/src;      ../Drivers/CMSIS/Include;      ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: fatfs.c stm32f0xx_hal_msp.c user_diskio.c stm32f0xx_it.c main.c axdl345.c helpers.c minmea.c sd_util.c sleep.c
    ../Inc/: axdl345.h fatfs.h ffconf.h helpers.h minmea.h mxconstants.h sd_util.h shared.h sleep.h stm32f0xx_hal_conf.h stm32f0xx_it.h user_diskio.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_flash.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 4.1.0
